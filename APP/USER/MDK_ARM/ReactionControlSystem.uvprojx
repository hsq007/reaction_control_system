# Keil uVision project ReactionControlSystem.uvprojx, settings and files
target ReactionControlSystem (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ReactionControlSystem
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\API;..\..\USER;..\..\..\HARDWARE;..\..\..\STM32F10x_FWLib\inc;..\..\..\CORE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app/user
    ../: main.c stm32f10x_it.c system_stm32f10x.c
    ../../../CORE/: startup_stm32f10x_md.s
  group app/api
    ../../API/: lpf.c pid.c user_math.c rcs.c
  group core
    ../../../CORE/: core_cm3.c
  group hardware
    ../../../HARDWARE/: led.c systick.c
  group stm32f10x
    ../../../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group readme
    ../../../: README.TXT
